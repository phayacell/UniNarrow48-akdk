## boards/shields/uninarrow48/Kconfig.defconfig
```kconfig
if SHIELD_UNINARROW48

config ZMK_KEYBOARD_NAME
    default "uninarrow48"

endif
```
